# IAR project LogicAnalyzer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F042F6 ST STM32F042F6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F042x6
  ICCARM.CCIncludePath2: Inc; STM32_USB_Device_Driver\inc; STM32_USB_Device_Library\Core\inc; STM32_USB_Device_Library\Class\hid\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PCB_RulerII_LogicAnalyzer.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32F042x6
  ICCARM.CCOptStrategy: 0
  group STM32F0_USB_Device_Library/Class/HID
    STM32_USB_Device_Library/Class/hid/src/: usbd_custom_hid_core.c
  group STM32F0_USB_Device_Library/Driver
    STM32_USB_Device_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group STM32F0_USB_Device_Library/Library
    STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group System
    Src/: startup_stm32f042.s system_stm32f0xx.c
  group User
    Src/: Analyzer_USB.c main.c stm32f0xx_it.c usb_bsp.c usbd_desc.c usbd_pwr.c usbd_usr.c
